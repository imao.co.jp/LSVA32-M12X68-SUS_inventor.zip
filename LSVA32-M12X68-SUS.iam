# Autodesk Inventor assembly: LSVA32-M12X68-SUS.x_
Saved by Autodesk Inventor 2022.5 (Build 265521000, 521)
## iProperties
Created: 2024-08
Part Number: LSVA32-M12X68-SUS.x_
Document SubType Name: Assembly
Designer: ImaoCorp
Author: ImaoCorp
Sending System: SOLIDWORKS 2022-2022290
MC: AMD64
MC_MODEL: Intel64 Family 6 Model 60 Stepping 3, GenuineIntel
OS: Windows_NT
FRU: Parasolid Version 33.1, build 260,  4-25-2022
FORMAT: text
GUISE: transmit
KEY: FILELSVA32-M12X68-SUS.x_t
DATE: Fri Aug 23 16:06:39 2024
## Documents named in this file (4)
- X:\14_SW2022-Inv2022\06_2024-10新製品(SME)\ELS_データ\l\lsva32-m12x68-sus\LSVA32-M12X68-SUS.x_.iam
- X:\14_SW2022-Inv2022\06_2024-10新製品(SME)\ELS_データ\l\lsva32-m12x68-sus\LSVA32-M12X68-SUS_01.ipt
- X:\14_SW2022-Inv2022\06_2024-10新製品(SME)\ELS_データ\l\lsva32-m12x68-sus\LSVA32-M12X68-SUS_02.ipt
- X:\14_SW2022-Inv2022\06_2024-10新製品(SME)\ELS_データ\l\lsva32-m12x68-sus\LSVA32-M12X68-SUS_03.ipt
## Components (3 placed, 3 different names)
1. LSVA32-M12X68-SUS_01
2. LSVA32-M12X68-SUS_02
3. LSVA32-M12X68-SUS_03
